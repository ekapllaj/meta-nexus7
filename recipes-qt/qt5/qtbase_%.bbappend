# set correct compile flags for tegra 3 gpu
QT_CONFIG_FLAGS +=" -qpa xcb -no-eglfs -opengl es2 -qt-xcb -fontconfig -no-kms "
